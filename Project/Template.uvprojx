# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030
  c include: ..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\include;..\Libraries\CMSIS\STM32F0xx\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../User/: main.c
    ../Libraries/CMSIS/STM32F0xx/: stm32f0xx_it.c
  group StartUp
    ../Libraries/CMSIS/STM32F0xx/startup/: startup_stm32f030.s
  group CMSIS
    ../Libraries/CMSIS/STM32F0xx/: system_stm32f0xx.c
    ../Libraries/CMSIS/STM32F0xx/include/: stm32f0xx.h stm32f0xx_conf.h stm32f0xx_it.h system_stm32f0xx.h
  group Doc
    ../Doc/: Readme.txt
